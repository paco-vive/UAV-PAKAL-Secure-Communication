options:
  parameters:
    generate_options: qt_gui
    id: marzo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitud
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '2437000000'
  states: {}
- name: hop_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: hop_rate
  id: variable_qtgui_range
  parameters:
    label: Velocidad salto
    start: '1'
    step: '1'
    stop: '200'
    value: '10'
  states: {}
- name: hop_spacing
  id: variable_qtgui_range
  parameters:
    label: Espacio entre frecs
    start: '100000'
    step: '50000'
    stop: '2000000'
    value: '500000'
  states: {}
- name: pattern
  id: variable_qtgui_range
  parameters:
    label: Patrón salto
    start: '0'
    step: '1'
    stop: '4'
    value: '0'
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    label: Fase (rad)
    start: '0'
    step: '0.01'
    stop: '6.28'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: signal_bw
  id: variable_qtgui_range
  parameters:
    label: Ancho de banda
    start: '100000'
    step: '10000'
    stop: '2000000'
    value: '500000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, samp_rate=10e6, hop_rate=10, hop_spacing=500e3, pattern=0):
              gr.sync_block.__init__(
                  self,
                  name='Freq Hopper',
                  in_sig=None,
                  out_sig=[np.complex64]
              )
              self.samp_rate = samp_rate
              self._hop_rate = hop_rate
              self._hop_spacing = hop_spacing
              self._pattern = pattern
              self.phase = 0.0
              self.sample_count = 0
              self.current_hop = 0
              self._build_table()
              self._update_samples_per_hop()

          def _build_table(self):
              n = 11  # número de frecuencias en la tabla
              spacing = self._hop_spacing
              
              if self._pattern == 0:
                  # Escalera izquierda a derecha (lo que tienes ahora)
                  self.hop_table = [i * spacing - 5 * spacing for i in range(n)]
              elif self._pattern == 1:
                  # Escalera derecha a izquierda
                  self.hop_table = [5 * spacing - i * spacing for i in range(n)]
              elif self._pattern == 2:
                  # Aleatorio (más realista, como Skylink real)
                  rng = np.random.default_rng(42)
                  self.hop_table = list(rng.permutation(
                      [i * spacing - 5 * spacing for i in range(n)]
                  ))
              elif self._pattern == 3:
                  # Zigzag: izquierda-derecha alternando
                  base = [i * spacing - 5 * spacing for i in range(n)]
                  self.hop_table = base[::2] + base[1::2]
              elif self._pattern == 4:
                  # Solo extremos: salta entre borde izquierdo y derecho
                  self.hop_table = [-5*spacing, 5*spacing] * 5

          def _update_samples_per_hop(self):
              self.samples_per_hop = max(1, int(self.samp_rate / self._hop_rate))

          # Setters para actualizar en caliente desde QT Range
          @property
          def hop_rate(self):
              return self._hop_rate
          @hop_rate.setter
          def hop_rate(self, val):
              self._hop_rate = val
              self._update_samples_per_hop()

          @property
          def hop_spacing(self):
              return self._hop_spacing
          @hop_spacing.setter
          def hop_spacing(self, val):
              self._hop_spacing = val
              self._build_table()

          @property
          def pattern(self):
              return self._pattern
          @pattern.setter
          def pattern(self, val):
              self._pattern = int(val)
              self.current_hop = 0
              self._build_table()

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              for i in range(n):
                  if self.sample_count >= self.samples_per_hop:
                      self.current_hop = (self.current_hop + 1) % len(self.hop_table)
                      self.sample_count = 0
                  freq = self.hop_table[self.current_hop]
                  self.phase += 2 * np.pi * freq / self.samp_rate
                  self.phase %= 2 * np.pi
                  out[i] = np.exp(1j * self.phase).astype(np.complex64)
                  self.sample_count += 1
              return n
    hop_rate: hop_rate
    hop_spacing: hop_spacing
    pattern: pattern
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: signal_bw / 2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: samp_rate
    freq0: center_freq
    gain0: '30'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
