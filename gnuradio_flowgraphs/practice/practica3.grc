options:
  parameters:
    generate_options: qt_gui
    id: practica1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: '157079'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    fc: '0'
    fftsize: '1024'
    name: '"Señal de dron"'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_f_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
